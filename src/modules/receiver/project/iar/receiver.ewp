# IAR project receiver.ewp, settings and files
configuration nrf51822_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51822_xxac nRF51822_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_CUSTOM; NRF51; DEBUG; DEBUG_NRF
  ICCARM.CCIncludePath2: ..\..\config\receiver; ..\..\config; ..\..\..\..\modules\common; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\rtc; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\radio_config; ..\..\..\..\..\components\libraries\util; ..\..\..\..\bsp; ..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  AARM.AUserIncludes: ..\..\config\receiver; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\rtc; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\libraries\util; ..\..\..\..\bsp; ..\..
  OBJCOPY.OOCOutputFile: receiver.hex
  ILINK.IlinkOutputFile: receiver.out
  ILINK.IlinkIcfFile: receiver.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../: main.c
    ../../../common/: radio.c role.c rtc.c stat.c uart.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c nrf_assert.c
